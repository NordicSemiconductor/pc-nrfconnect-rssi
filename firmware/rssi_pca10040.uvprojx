# Keil uVision project rssi_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: USE_APP_CONFIG BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74
  c misc: --reduce_paths
  c include: .;sdk\config\uart_pca10040;sdk\config;sdk\components;sdk\components\boards;sdk\components\drivers_nrf\common;sdk\components\drivers_nrf\delay;sdk\components\drivers_nrf\hal;sdk\components\drivers_nrf\nrf_soc_nosd;sdk\components\drivers_nrf\uart;sdk\components\libraries\bsp;sdk\components\libraries\fifo;sdk\components\libraries\log;sdk\components\libraries\log\src;sdk\components\libraries\strerror;sdk\components\libraries\uart;sdk\components\libraries\util;sdk\components\toolchain;sdk\components\libraries\timer
  asm define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  asm include: sdk\config\uart_pca10040;sdk\config;sdk\components;sdk\components\boards;sdk\components\drivers_nrf\common;sdk\components\drivers_nrf\delay;sdk\components\drivers_nrf\hal;sdk\components\drivers_nrf\nrf_soc_nosd;sdk\components\drivers_nrf\uart;sdk\components\libraries\bsp;sdk\components\libraries\fifo;sdk\components\libraries\log;sdk\components\libraries\log\src;sdk\components\libraries\strerror;sdk\components\libraries\uart;sdk\components\libraries\util;sdk\components\toolchain
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
  group Board Definition
    sdk/components/boards/: boards.c
  group nRF_Drivers
    sdk/components/drivers_nrf/common/: nrf_drv_common.c
    sdk/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    sdk/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    sdk/components/libraries/fifo/: app_fifo.c
    sdk/components/libraries/uart/: app_uart_fifo.c retarget.c
    sdk/components/libraries/strerror/: nrf_strerror.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1, Device:StartupConfig 8.12.0
